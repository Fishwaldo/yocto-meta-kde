# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/systemsettings-${PV}.tar.xz"
SRC_URI[sha256sum] = "7c1dda144c7bcd6468331895a37df19d352cc84732a3d60bd62741a6c9aa6c6e"


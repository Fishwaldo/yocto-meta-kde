# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-bigscreen-${PV}.tar.xz"
SRC_URI[sha256sum] = "2ba028fe522e29bdc45a928fc41d92b9ba0471600ddb40d5a952e8c04b035c2c"


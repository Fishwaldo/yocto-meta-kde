# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-bigscreen-${PV}.tar.xz"
SRC_URI[sha256sum] = "76808ec3d1b6733dfea20999e9feb745562ceb8d490f841f154895cf00054bf1"


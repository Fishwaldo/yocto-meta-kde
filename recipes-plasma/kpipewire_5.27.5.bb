# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kpipewire-${PV}.tar.xz"
SRC_URI[sha256sum] = "41326adceeaad0d5e0fba78af69403dea12c007b769ed4b5d5534c21f27bdd98"


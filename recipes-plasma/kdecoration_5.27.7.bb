# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kdecoration-${PV}.tar.xz"
SRC_URI[sha256sum] = "ef26a499d51f4da9e6c25a0209d08b5e8dcedddc86e066537f46f20f001f7294"


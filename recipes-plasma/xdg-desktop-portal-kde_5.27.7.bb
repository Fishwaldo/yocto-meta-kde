# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/xdg-desktop-portal-kde-${PV}.tar.xz"
SRC_URI[sha256sum] = "ccdbf9bad6465de934c4dc30a6fb4d4376872caf0014b91c3749e27140fe08cd"


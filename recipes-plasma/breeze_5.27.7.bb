# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/breeze-${PV}.tar.xz"
SRC_URI[sha256sum] = "bffdcf314009b6fcb0202a58e48b3e62a4cbf741f5f299c257998f46dea4ccf1"


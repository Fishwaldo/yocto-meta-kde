# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kscreen-${PV}.tar.xz"
SRC_URI[sha256sum] = "38d755e1b01584e1c21a925b2ab046c0f8f977bb1c4e75d436ebc9c633160a0f"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kwayland-integration-${PV}.tar.xz"
SRC_URI[sha256sum] = "9ae1fc40a70d1453841e16dca2e399fc5c68de3a9ffa7475673f98bf7dcb18f9"


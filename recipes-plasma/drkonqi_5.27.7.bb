# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/drkonqi-${PV}.tar.xz"
SRC_URI[sha256sum] = "e82716415c22a3d6cf90e2380a64cbf5d7d171ab32d02cd29056bced0b9221d2"


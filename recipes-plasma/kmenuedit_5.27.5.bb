# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kmenuedit-${PV}.tar.xz"
SRC_URI[sha256sum] = "446263c4bcc4592251c0e93f3bbab1635452b26e5650605928d4933d70f31127"


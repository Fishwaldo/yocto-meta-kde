# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-mobile-${PV}.tar.xz"
SRC_URI[sha256sum] = "cc1b2fbb64291fd63a498b7f9c8139e6a8a6a6a0a30c505f6eaa503e2dc2c140"


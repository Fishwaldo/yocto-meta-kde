# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-pa-${PV}.tar.xz"
SRC_URI[sha256sum] = "4c73fb72af73a5258fb7d384eea65084b76341ae9c55652a491e1163cb46e2ed"


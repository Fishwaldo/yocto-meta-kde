# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.7/plasma-sdk-${PV}.tar.xz"
SRC_URI[sha256sum] = "d310a81eed68334886a7e7767bce9066c6ccb07087aa77d04b73acf41a5426a4"


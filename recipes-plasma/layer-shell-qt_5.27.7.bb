# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/layer-shell-qt-${PV}.tar.xz"
SRC_URI[sha256sum] = "27c44e7db73bf2aa6728719e8bb848c1b0c1c7a704c86349a419577920c6f421"


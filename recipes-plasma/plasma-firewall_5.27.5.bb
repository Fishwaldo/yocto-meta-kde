# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-firewall-${PV}.tar.xz \
           "
SRC_URI[sha256sum] = "e32c90aa52ec35d35fd04e04d00989f18d43ea1f7b244e53de7feb7745235b41"


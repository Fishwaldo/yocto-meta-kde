# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kactivitymanagerd-${PV}.tar.xz"
SRC_URI[sha256sum] = "a209f4727bc5c44754f48ed1947fbe66419877407f83a0bad458dcab2d03b619"


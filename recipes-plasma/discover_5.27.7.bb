# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/discover-${PV}.tar.xz"
SRC_URI[sha256sum] = "a9eca14bb4cf3094d5c4df7975f1a793fca8fb4018ca1252d1e1230c79784500"


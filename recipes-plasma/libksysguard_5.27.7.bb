# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/libksysguard-${PV}.tar.xz"
SRC_URI[sha256sum] = "682a939252e35a52b7f95a6f5bfcc7cb983fa3b5275ae3b377ab8040b292cb18"


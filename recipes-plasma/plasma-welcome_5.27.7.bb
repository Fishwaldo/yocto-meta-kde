# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-welcome-${PV}.tar.xz"
SRC_URI[sha256sum] = "3de80966c3bd5cf885a7f49288861cde0d0ab4396a4c53971ef46d5b7e87e15b"


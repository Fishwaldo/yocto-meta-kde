# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kde-cli-tools-${PV}.tar.xz"
SRC_URI[sha256sum] = "ed745637701210102e0e2e1354823e4e0f2bf8b7d4778cf5ed9c104fb57cef67"


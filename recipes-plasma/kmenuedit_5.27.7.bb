# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kmenuedit-${PV}.tar.xz"
SRC_URI[sha256sum] = "67abf2bf9166c0c7797442edcfc5d6f7eba4a575ac689859b651eac509f9c058"


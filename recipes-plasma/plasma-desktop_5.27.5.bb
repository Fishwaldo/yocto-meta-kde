# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-desktop-${PV}.tar.xz"
SRC_URI[sha256sum] = "4f2b573134658f640717d6ee67eaee41d9df4c578856016efa769b4415e91cb1"


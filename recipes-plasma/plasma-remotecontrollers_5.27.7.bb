# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-remotecontrollers-${PV}.tar.xz"
SRC_URI[sha256sum] = "50ad6f6fdc7a0899a6d8e4544b1668a2957bd8bc8fa8e2b7ddc5c191de945c47"


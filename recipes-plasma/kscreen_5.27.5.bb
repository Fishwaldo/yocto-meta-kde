# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kscreen-${PV}.tar.xz"
SRC_URI[sha256sum] = "7297aac39b79d477ecd66df5a5c464d2064d375e7b2249eb67f62195a9824468"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/aura-browser-${PV}.tar.xz"
SRC_URI[sha256sum] = "b900d163bebb9a74cd92ed2091363a1a14c266849d339f586b3a618c1f1feb5f"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kwrited-${PV}.tar.xz"
SRC_URI[sha256sum] = "16ec41745cbbe5c162d5808ab24663dc74248c719d324c81047fd1657d018fa8"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-nm-${PV}.tar.xz"
SRC_URI[sha256sum] = "488a34118e6070fab5005cf092d9332bbc6c415dab6aa8387e08560123653ff1"


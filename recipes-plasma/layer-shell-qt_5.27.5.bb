# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/layer-shell-qt-${PV}.tar.xz"
SRC_URI[sha256sum] = "ccdf6aa579f0437f3bad377ac35268dfab36f6816227c03bae0591301c8d1d21"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-workspace-wallpapers-${PV}.tar.xz"
SRC_URI[sha256sum] = "dec571ce370ea344a70d82f16af82e8197c8afc098c0e7d47fbe8d5b6b0538a0"


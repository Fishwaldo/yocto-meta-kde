# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/milou-${PV}.tar.xz"
SRC_URI[sha256sum] = "1b1b0a3e672f06eb81f889b0c48726af4b3702b103eb1e680c3972ef5c8d0298"


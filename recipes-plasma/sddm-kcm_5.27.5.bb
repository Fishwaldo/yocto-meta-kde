# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/sddm-kcm-${PV}.tar.xz"
SRC_URI[sha256sum] = "5605f2dffe33b731b08ec51b7ef4cea8ec6fb796497ae46242fe8f40e8aa199a"


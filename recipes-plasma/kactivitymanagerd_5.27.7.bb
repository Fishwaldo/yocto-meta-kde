# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kactivitymanagerd-${PV}.tar.xz"
SRC_URI[sha256sum] = "2df245330612d79090980269ad7c4e776150598e583761ac83f628cc1ffafbb4"


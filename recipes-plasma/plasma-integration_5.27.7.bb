# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-integration-${PV}.tar.xz"
SRC_URI[sha256sum] = "e3f266c60efb3d96f3a22782ba81b7c7071b010484ea717a169327c3f6641faa"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/powerdevil-${PV}.tar.xz"
SRC_URI[sha256sum] = "0379862c57efef4ce980f6c9583d66deafde1ed522f0e129aa50cef038fb500e"


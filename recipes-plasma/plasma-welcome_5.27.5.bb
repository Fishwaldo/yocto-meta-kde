# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-welcome-${PV}.tar.xz"
SRC_URI[sha256sum] = "cbc98ef1b003116976b605d9a88bd9027af0a5431de898bc459a31a142f4aeb5"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-vault-${PV}.tar.xz"
SRC_URI[sha256sum] = "181aba6b37ee065f7354c5df2963db68eb01400da8531cda62a0acaa682eb5dc"


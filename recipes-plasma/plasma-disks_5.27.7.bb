# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-disks-${PV}.tar.xz"
SRC_URI[sha256sum] = "3ba9b69e269420f73fecf894e65061b36a75d197a29fca04e5b0069581d8924b"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/powerdevil-${PV}.tar.xz"
SRC_URI[sha256sum] = "c08084238b8e2225dcaf36226e69476e7ce0d427597708e598720c59dc853894"


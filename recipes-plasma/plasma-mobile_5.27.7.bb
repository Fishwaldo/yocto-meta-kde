# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-mobile-${PV}.tar.xz"
SRC_URI[sha256sum] = "16d8c782efff20843f9150169411be9e7187bba8bc6a0edb4dc889b193ec6238"


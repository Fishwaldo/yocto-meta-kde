# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kdecoration-${PV}.tar.xz"
SRC_URI[sha256sum] = "effbf6c5c79802d07fa14f8bd40a9d57bbfc2af2861b6ed596687db48230be42"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/oxygen-${PV}.tar.xz"
SRC_URI[sha256sum] = "a218fc2f2f7b297de56b75f413c5acab0398f8c4a7a043a1b99b99d15256398d"


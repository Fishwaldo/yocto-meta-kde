# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/polkit-kde-agent-1-${PV}.tar.xz"
SRC_URI[sha256sum] = "8c4906f13f0a8b31423f6e2eb42163fea3a9517adec518b3f165d99acab6cf5c"


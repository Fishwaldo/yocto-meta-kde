# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-systemmonitor-${PV}.tar.xz"
SRC_URI[sha256sum] = "82e551398f208270f543d5f91be6f3f3b27b1ce9f2c0e90263f29f8d238b2e34"


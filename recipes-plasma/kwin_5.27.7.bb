# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kwin-${PV}.tar.xz"
SRC_URI[sha256sum] = "cbff55ba018463bc05ba286663aea1d7b0f48993dc3c778b5514e34fcdb95a2f"


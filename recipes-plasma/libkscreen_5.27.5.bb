# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/libkscreen-${PV}.tar.xz"
SRC_URI[sha256sum] = "29aff3f28d8706e864b914dea4ab59e5518ed0381bb1c6625f454f08196deb65"


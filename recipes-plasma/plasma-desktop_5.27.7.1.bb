# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.7/plasma-desktop-${PV}.tar.xz"
SRC_URI[sha256sum] = "51626674ce4324ac424fded716862da967e6b33a898108b49fa27a7896d1bec2"


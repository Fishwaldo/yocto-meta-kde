# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/sddm-kcm-${PV}.tar.xz"
SRC_URI[sha256sum] = "0645f5511c99cd2f01963cf0e01ccfe248bbca33daf349c729f0fe0ca3103c43"


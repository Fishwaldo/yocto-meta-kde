# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/libksysguard-${PV}.tar.xz"
SRC_URI[sha256sum] = "7e7eb53af05fefcfea6b38fed4947409370ad303247892e4719bc2a809e85e14"


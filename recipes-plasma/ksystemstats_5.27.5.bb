# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/ksystemstats-${PV}.tar.xz"
SRC_URI[sha256sum] = "d59d84cdf8c9cd8a2c3639ebb5986f50995f1f7f74a833af867709b7c336dcf8"


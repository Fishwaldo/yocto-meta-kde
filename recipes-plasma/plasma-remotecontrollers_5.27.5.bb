# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-remotecontrollers-${PV}.tar.xz"
SRC_URI[sha256sum] = "8c7afc00d19f24b266f6eb6c4edf0f11257a0088d6ed45534a76ab2bc9cda011"


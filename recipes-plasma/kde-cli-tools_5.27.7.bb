# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kde-cli-tools-${PV}.tar.xz"
SRC_URI[sha256sum] = "aadb24e6153451111c22574ee27b1e562ba5e923f0a260a817ed58a2168a21af"


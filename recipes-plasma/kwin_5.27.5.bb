# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kwin-${PV}.tar.xz"
SRC_URI[sha256sum] = "bb1226b15919681ea5f1de58b24ea4b568ea3f2b5452411f76daa80eb30c20ea"


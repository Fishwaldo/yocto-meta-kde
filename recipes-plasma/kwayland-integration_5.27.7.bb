# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kwayland-integration-${PV}.tar.xz"
SRC_URI[sha256sum] = "1e7997688a329563f62ce7534e82326a4317d9ecf12403d12e70d4d237316ebb"


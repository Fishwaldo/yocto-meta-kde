# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/bluedevil-${PV}.tar.xz"
SRC_URI[sha256sum] = "61535ae665a5bc1e17c8210d660ba79a3a694ae4ca4b3016e6523ab227a54ded"


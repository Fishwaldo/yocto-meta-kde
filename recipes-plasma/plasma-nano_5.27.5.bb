# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-nano-${PV}.tar.xz"
SRC_URI[sha256sum] = "92c2ec3f792725f41b13c556c27351d3d51d82bd3475e7a5c0742c9bb9c1d7f0"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/${PV}/plasma-workspace-${PV}.tar.xz"
SRC_URI[sha256sum] = "0642941dcdf513ac201494897e2c5097a2f2db8be6dcdb597cae1a43d82ece5f"


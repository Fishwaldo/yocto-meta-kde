# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/xdg-desktop-portal-kde-${PV}.tar.xz"
SRC_URI[sha256sum] = "7cfa3f24cff9b18baeef245e122f969092a89c41d872ea5a8df628061d8f1aab"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-pa-${PV}.tar.xz"
SRC_URI[sha256sum] = "c2ab3f73bfdeed68a5cda3bf72a67ef609bef1c3e96e43bab0a18df822d98188"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-integration-${PV}.tar.xz"
SRC_URI[sha256sum] = "8dedc5630828f0fb5912ca7cad9df5cde2492e17fd2956de6f514d43b4f89f7b"


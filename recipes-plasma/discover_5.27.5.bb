# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/discover-${PV}.tar.xz"
SRC_URI[sha256sum] = "785f788a16e065d28f6422274e2d5a7bcbe63b0f5814206c50c401a3003ab31b"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/milou-${PV}.tar.xz"
SRC_URI[sha256sum] = "81690bffc9d58445c09af64670d80cd53735db2f0da36a4847d3466ec5a90853"


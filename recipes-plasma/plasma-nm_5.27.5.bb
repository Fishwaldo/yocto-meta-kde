# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-nm-${PV}.tar.xz"
SRC_URI[sha256sum] = "152f48e44b6207a606b89548c9f298f1a12a9778ff4876c3ffeeb1f2188ca62e"


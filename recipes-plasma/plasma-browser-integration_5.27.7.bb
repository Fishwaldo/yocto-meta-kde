# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-browser-integration-${PV}.tar.xz"
SRC_URI[sha256sum] = "3ee5b893a210f84849612c48c03c544b611800edbc1ed6ae5ca2100a69bb6030"


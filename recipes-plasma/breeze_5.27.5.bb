# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/breeze-${PV}.tar.xz"
SRC_URI[sha256sum] = "70d8a35bf8c0758f9c3e3873b657250b1e09c1c79f92b066d3385a1e44fec868"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kpipewire-${PV}.tar.xz"
SRC_URI[sha256sum] = "0ad273b8875c0472e0b4f4332c9f1a5d93dca6533f978fd0606094bd91d24782"


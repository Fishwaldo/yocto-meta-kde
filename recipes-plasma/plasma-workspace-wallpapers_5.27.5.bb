# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-workspace-wallpapers-${PV}.tar.xz"
SRC_URI[sha256sum] = "23805edcc147377c7bd7444278e76327003d142f9c4048e3970000cb6f38c840"


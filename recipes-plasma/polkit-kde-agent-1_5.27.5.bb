# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/polkit-kde-agent-1-${PV}.tar.xz"
SRC_URI[sha256sum] = "2ae3b4ff0c74d9f55fe85cb0fb8106401f0301a96760d0ffefb66161215a2a2f"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kinfocenter-${PV}.tar.xz"
SRC_URI[sha256sum] = "72ee8872213f08c2d910e82712db2d24773c28701cdbb9e7d23f671791401596"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-browser-integration-${PV}.tar.xz"
SRC_URI[sha256sum] = "b490451d672bb2f0294f53422d41df7594690bc8761f9724081147d5fdd1d925"


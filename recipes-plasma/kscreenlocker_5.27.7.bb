# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kscreenlocker-${PV}.tar.xz"
SRC_URI[sha256sum] = "c2013b510ed714b0f2544b37393b82cb1d6699dec829c8906d10dd249a9ec387"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/aura-browser-${PV}.tar.xz"
SRC_URI[sha256sum] = "c56f5d69acd76d22f199ae42ce46fee1f82db8ce70b9fc1c376df4a9fb4c1c6f"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-sdk-${PV}.tar.xz"
SRC_URI[sha256sum] = "f10245b27687bbd21b18e78267a1895aab9644722456a2b92fb54f7ca0b06915"


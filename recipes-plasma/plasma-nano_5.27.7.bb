# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-nano-${PV}.tar.xz"
SRC_URI[sha256sum] = "d32a4a833f39c94c53bf3c64174338c226582e42eb93ff42f9a071db97398c93"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/bluedevil-${PV}.tar.xz"
SRC_URI[sha256sum] = "cbc1aea8cceefd68a015098101de669df9a4d619a7a7baeb823b1b60b362bf35"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kscreenlocker-${PV}.tar.xz"
SRC_URI[sha256sum] = "4c8807f1c2ed8fa14a9b29639c7d5697b5d5bab44d6b88020e5d3f463880ec92"


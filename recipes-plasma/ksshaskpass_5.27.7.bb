# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/ksshaskpass-${PV}.tar.xz"
SRC_URI[sha256sum] = "e13175acf1ac1eb95a2454ab30b57e1e829a32145a7acf931f892546e46ebe6e"


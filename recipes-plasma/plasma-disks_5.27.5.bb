# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-disks-${PV}.tar.xz"
SRC_URI[sha256sum] = "ea10e289596b3ce53c0d6ea5ee714306918c5b7368262c22965f44a1dab1480b"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-vault-${PV}.tar.xz"
SRC_URI[sha256sum] = "74f22be02ae0e02cf2e9eb3fad62a5ca9fb5f984775455f6c7e1c6aa553527e8"


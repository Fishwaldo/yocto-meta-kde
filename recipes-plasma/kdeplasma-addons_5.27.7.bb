# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/kdeplasma-addons-${PV}.tar.xz"
SRC_URI[sha256sum] = "51c73d8872fce7f3bc54a8fbf480a40c0178d63f703fe696721d046f3a25ef50"

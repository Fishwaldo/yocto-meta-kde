# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.5/plasma-workspace-${PV}.tar.xz"
SRC_URI[sha256sum] = "ed0b95b2eefd0782ea652c2c6eed262e8eb91f97ff72925bb3f7e161d1f72a17"


# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plank-player-${PV}.tar.xz"
SRC_URI[sha256sum] = "f066b51434b2623441a0a96cd41ddfa397c2fcae383747d2051837796dd1dc2a"


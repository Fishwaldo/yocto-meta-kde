# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/systemsettings-${PV}.tar.xz"
SRC_URI[sha256sum] = "d5454eb0aaba331e724bd91650474bbe1658f26fcc543ab7804186bccf50b4db"


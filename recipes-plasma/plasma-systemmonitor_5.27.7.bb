# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/${PV}/plasma-systemmonitor-${PV}.tar.xz"
SRC_URI[sha256sum] = "14611b425b1817743acaf594005f16a6ae347b063182fec0ee1f8676589e28e3"

